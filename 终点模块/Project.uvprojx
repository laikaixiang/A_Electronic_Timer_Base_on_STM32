# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\code;.\Start;.\Library;.\User;.\System;.\Hardware;.\Hardware\VL53L0X;.\Hardware\VL53L0X\Platform;.\Hardware\VL53L0X\ST-API;.\Hardware\VL53L0X\VL53L0X
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h Timer.c Timer.h MYIIC.h MYIIC.c
  group Hardware
    ./Hardware/: LED.c LED.h Key.c Key.h Buzzer.c Buzzer.h LightSensor.c LightSensor.h seg_display.c seg_display.h NRF24L01.c NRF24L01.h NRF24L01_Define.h Max7219_display.c Max7219_display.h VL53L0X.c VL53L0X.h
  group code
    ./code/: main.c main.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main_all.c main_logic.c main_logic.h test.c
  group VL53L0X_driver
    ./Hardware/VL53L0X/ST-API/: vl53l0x_api.c vl53l0x_api.h vl53l0x_api_calibration.c vl53l0x_api_calibration.h vl53l0x_api_core.c vl53l0x_api_core.h vl53l0x_api_ranging.c vl53l0x_api_ranging.h vl53l0x_api_strings.c vl53l0x_api_strings.h vl53l0x_def.h vl53l0x_device.h vl53l0x_gen.h vl53l0x_interrupt_threshold_settings.h vl53l0x_tuning.h
    ./Hardware/VL53L0X/Platform/: vl53l0x_i2c.c vl53l0x_i2c.h vl53l0x_types.h vl53l0x_platform.c vl53l0x_platform.h
